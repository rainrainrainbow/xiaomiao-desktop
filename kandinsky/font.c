/**
 * @file kandinsky/font.c
 * @brief Kandinsky - Graphics Engine: Font Implementation
 *
 * 字体渲染实现。支持：
 * - 内置 5x7 像素 ASCII 字体（最小字体）
 * - LVGL 字体桥接（通过 lvgl 字体渲染）
 * - 字符宽度计算
 * - 字符串渲染（自动换行可选）
 */

#include "kandinsky/font.h"
#include "kandinsky/canvas.h"
#include <string.h>
#include <stdint.h>

/* ========== 内置 5x7 像素点阵字体（ASCII 32-126） ========== */

/* 每个字符 5 字节，每字节代表一列，仅低 7 位有效 */
static const uint8_t s_font5x7[] = {
    /* 32 Space */ 0x00, 0x00, 0x00, 0x00, 0x00,
    /* 33 ! */     0x00, 0x00, 0x5F, 0x00, 0x00,
    /* 34 " */     0x00, 0x07, 0x00, 0x07, 0x00,
    /* 35 # */     0x14, 0x7F, 0x14, 0x7F, 0x14,
    /* 36 $ */     0x24, 0x2A, 0x7F, 0x2A, 0x12,
    /* 37 % */     0x23, 0x13, 0x08, 0x64, 0x62,
    /* 38 & */     0x36, 0x49, 0x55, 0x22, 0x50,
    /* 39 ' */     0x00, 0x05, 0x03, 0x00, 0x00,
    /* 40 ( */     0x00, 0x1C, 0x22, 0x41, 0x00,
    /* 41 ) */     0x00, 0x41, 0x22, 0x1C, 0x00,
    /* 42 * */     0x08, 0x2A, 0x1C, 0x2A, 0x08,
    /* 43 + */     0x08, 0x08, 0x3E, 0x08, 0x08,
    /* 44 , */     0x00, 0x50, 0x30, 0x00, 0x00,
    /* 45 - */     0x08, 0x08, 0x08, 0x08, 0x08,
    /* 46 . */     0x00, 0x60, 0x60, 0x00, 0x00,
    /* 47 / */     0x20, 0x10, 0x08, 0x04, 0x02,
    /* 48 0 */     0x3E, 0x51, 0x49, 0x45, 0x3E,
    /* 49 1 */     0x00, 0x42, 0x7F, 0x40, 0x00,
    /* 50 2 */     0x42, 0x61, 0x51, 0x49, 0x46,
    /* 51 3 */     0x21, 0x41, 0x45, 0x4B, 0x31,
    /* 52 4 */     0x18, 0x14, 0x12, 0x7F, 0x10,
    /* 53 5 */     0x27, 0x45, 0x45, 0x45, 0x39,
    /* 54 6 */     0x3C, 0x4A, 0x49, 0x49, 0x30,
    /* 55 7 */     0x01, 0x71, 0x09, 0x05, 0x03,
    /* 56 8 */     0x36, 0x49, 0x49, 0x49, 0x36,
    /* 57 9 */     0x06, 0x49, 0x49, 0x29, 0x1E,
    /* 58 : */     0x00, 0x36, 0x36, 0x00, 0x00,
    /* 59 ; */     0x00, 0x56, 0x36, 0x00, 0x00,
    /* 60 < */     0x00, 0x08, 0x14, 0x22, 0x41,
    /* 61 = */     0x14, 0x14, 0x14, 0x14, 0x14,
    /* 62 > */     0x41, 0x22, 0x14, 0x08, 0x00,
    /* 63 ? */     0x02, 0x01, 0x51, 0x09, 0x06,
    /* 64 @ */     0x32, 0x49, 0x79, 0x41, 0x3E,
    /* 65 A */     0x7E, 0x11, 0x11, 0x11, 0x7E,
    /* 66 B */     0x7F, 0x49, 0x49, 0x49, 0x36,
    /* 67 C */     0x3E, 0x41, 0x41, 0x41, 0x22,
    /* 68 D */     0x7F, 0x41, 0x41, 0x22, 0x1C,
    /* 69 E */     0x7F, 0x49, 0x49, 0x49, 0x41,
    /* 70 F */     0x7F, 0x09, 0x09, 0x01, 0x01,
    /* 71 G */     0x3E, 0x41, 0x41, 0x51, 0x32,
    /* 72 H */     0x7F, 0x08, 0x08, 0x08, 0x7F,
    /* 73 I */     0x00, 0x41, 0x7F, 0x41, 0x00,
    /* 74 J */     0x20, 0x40, 0x41, 0x3F, 0x01,
    /* 75 K */     0x7F, 0x08, 0x14, 0x22, 0x41,
    /* 76 L */     0x7F, 0x40, 0x40, 0x40, 0x40,
    /* 77 M */     0x7F, 0x02, 0x04, 0x02, 0x7F,
    /* 78 N */     0x7F, 0x04, 0x08, 0x10, 0x7F,
    /* 79 O */     0x3E, 0x41, 0x41, 0x41, 0x3E,
    /* 80 P */     0x7F, 0x09, 0x09, 0x09, 0x06,
    /* 81 Q */     0x3E, 0x41, 0x51, 0x21, 0x5E,
    /* 82 R */     0x7F, 0x09, 0x19, 0x29, 0x46,
    /* 83 S */     0x46, 0x49, 0x49, 0x49, 0x31,
    /* 84 T */     0x01, 0x01, 0x7F, 0x01, 0x01,
    /* 85 U */     0x3F, 0x40, 0x40, 0x40, 0x3F,
    /* 86 V */     0x1F, 0x20, 0x40, 0x20, 0x1F,
    /* 87 W */     0x7F, 0x20, 0x18, 0x20, 0x7F,
    /* 88 X */     0x63, 0x14, 0x08, 0x14, 0x63,
    /* 89 Y */     0x03, 0x04, 0x78, 0x04, 0x03,
    /* 90 Z */     0x61, 0x51, 0x49, 0x45, 0x43,
    /* 91 [ */     0x00, 0x00, 0x7F, 0x41, 0x41,
    /* 92 \ */     0x02, 0x04, 0x08, 0x10, 0x20,
    /* 93 ] */     0x41, 0x41, 0x7F, 0x00, 0x00,
    /* 94 ^ */     0x04, 0x02, 0x01, 0x02, 0x04,
    /* 95 _ */     0x40, 0x40, 0x40, 0x40, 0x40,
    /* 96 ` */     0x00, 0x01, 0x02, 0x04, 0x00,
    /* 97 a */     0x20, 0x54, 0x54, 0x54, 0x78,
    /* 98 b */     0x7F, 0x48, 0x44, 0x44, 0x38,
    /* 99 c */     0x38, 0x44, 0x44, 0x44, 0x20,
    /* 100 d */    0x38, 0x44, 0x44, 0x48, 0x7F,
    /* 101 e */    0x38, 0x54, 0x54, 0x54, 0x18,
    /* 102 f */    0x08, 0x7E, 0x09, 0x01, 0x02,
    /* 103 g */    0x08, 0x14, 0x54, 0x54, 0x3C,
    /* 104 h */    0x7F, 0x08, 0x04, 0x04, 0x78,
    /* 105 i */    0x00, 0x44, 0x7D, 0x40, 0x00,
    /* 106 j */    0x20, 0x40, 0x44, 0x3D, 0x00,
    /* 107 k */    0x00, 0x7F, 0x10, 0x28, 0x44,
    /* 108 l */    0x00, 0x41, 0x7F, 0x40, 0x00,
    /* 109 m */    0x7C, 0x04, 0x18, 0x04, 0x78,
    /* 110 n */    0x7C, 0x08, 0x04, 0x04, 0x78,
    /* 111 o */    0x38, 0x44, 0x44, 0x44, 0x38,
    /* 112 p */    0x7C, 0x14, 0x14, 0x14, 0x08,
    /* 113 q */    0x08, 0x14, 0x14, 0x18, 0x7C,
    /* 114 r */    0x7C, 0x08, 0x04, 0x04, 0x08,
    /* 115 s */    0x48, 0x54, 0x54, 0x54, 0x20,
    /* 116 t */    0x04, 0x3F, 0x44, 0x40, 0x20,
    /* 117 u */    0x3C, 0x40, 0x40, 0x20, 0x7C,
    /* 118 v */    0x1C, 0x20, 0x40, 0x20, 0x1C,
    /* 119 w */    0x3C, 0x40, 0x30, 0x40, 0x3C,
    /* 120 x */    0x44, 0x28, 0x10, 0x28, 0x44,
    /* 121 y */    0x0C, 0x50, 0x50, 0x50, 0x3C,
    /* 122 z */    0x44, 0x64, 0x54, 0x4C, 0x44,
    /* 123 { */    0x00, 0x08, 0x36, 0x41, 0x00,
    /* 124 | */    0x00, 0x00, 0x7F, 0x00, 0x00,
    /* 125 } */    0x00, 0x41, 0x36, 0x08, 0x00,
    /* 126 ~ */    0x08, 0x04, 0x08, 0x10, 0x08,
};

/* ========== 字体渲染功能 ========== */

/* 默认字体 */
static const kd_font_t *s_default_font = NULL;

/* 获取字体高度 */
int kd_font_height(const kd_font_t *font)
{
    if (!font) return 7;  /* 默认 5x7 字体高度 */
    return font->height;
}

/* 获取字符宽度 */
int kd_font_char_width(const kd_font_t *font, char c)
{
    if (!font || font->type == KD_FONT_5X7) {
        /* 5x7 字体，所有字符 5 像素宽，空格特殊处理 */
        if (c == ' ') return 4;
        return 5;
    }
    return font->width;
}

/* 计算字符串宽度 */
int kd_font_string_width(const kd_font_t *font, const char *str)
{
    if (!str) return 0;
    int w = 0;
    while (*str) {
        w += kd_font_char_width(font, *str) + 1;  /* 加 1 像素间距 */
        str++;
    }
    if (w > 0) w -= 1;  /* 去掉最后一个字符的间距 */
    return w;
}

/* 渲染 5x7 点阵字符 */
static void render_char_5x7(int x, int y, char c, ion_color_t fg, ion_color_t bg)
{
    if (c < 32 || c > 126) c = '?';
    int idx = (c - 32) * 5;

    for (int col = 0; col < 5; col++) {
        uint8_t bits = s_font5x7[idx + col];
        for (int row = 0; row < 7; row++) {
            if (bits & (1 << (6 - row))) {
                kd_canvas_set_pixel(x + col, y + row, fg);
            } else if (bg != 0xFFFF) {
                kd_canvas_set_pixel(x + col, y + row, bg);
            }
        }
    }
}

/* 渲染单个字符 */
void kd_font_draw_char(int x, int y, const kd_font_t *font, char c,
                        ion_color_t fg, ion_color_t bg)
{
    if (!font || font->type == KD_FONT_5X7) {
        render_char_5x7(x, y, c, fg, bg);
        return;
    }
    /* 外部字体（如 LVGL 字体）通过回调渲染 */
    if (font->render_char) {
        font->render_char(x, y, c, fg, bg);
    }
}

/* 渲染字符串 */
void kd_font_draw_string(int x, int y, const kd_font_t *font,
                          const char *str, ion_color_t fg, ion_color_t bg)
{
    if (!str) return;
    int px = x;
    int py = y;

    while (*str) {
        if (*str == '\n') {
            px = x;
            py += kd_font_height(font) + 2;
        } else {
            kd_font_draw_char(px, py, font, *str, fg, bg);
            px += kd_font_char_width(font, *str) + 1;
        }
        str++;
    }
}

/* 限制宽度内渲染字符串（自动换行） */
void kd_font_draw_string_wrap(int x, int y, const kd_font_t *font,
                               const char *str, int max_width,
                               ion_color_t fg, ion_color_t bg)
{
    if (!str || max_width <= 0) return;

    int px = x;
    int py = y;
    int fh = kd_font_height(font);

    while (*str) {
        if (*str == '\n') {
            px = x;
            py += fh + 2;
            str++;
            continue;
        }

        int cw = kd_font_char_width(font, *str) + 1;

        /* 检查是否需要换行 */
        if (px + cw > x + max_width) {
            px = x;
            py += fh + 2;
        }

        kd_font_draw_char(px, py, font, *str, fg, bg);
        px += cw;
        str++;
    }
}

/* 设置默认字体 */
void kd_font_set_default(const kd_font_t *font)
{
    s_default_font = font;
}

/* 获取默认字体 */
const kd_font_t *kd_font_get_default(void)
{
    return s_default_font;
}

/* ========== 预定义字体 ========== */

const kd_font_t kd_font_5x7 = {
    .type = KD_FONT_5X7,
    .width = 5,
    .height = 7,
    .render_char = NULL  /* 使用内置渲染 */
};